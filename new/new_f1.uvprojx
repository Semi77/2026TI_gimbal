# Keil uVision project new_f1.uvprojx, settings and files
target new_f1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: new_f1 +hex
  c flags: Optim=2 v6Lang=1 v6LangP=5
  c define: STM32F10X_ MD,USE_STDPERIPH_DRIVER
  c include: .;.\USER;.\MiniBalance_COER;.\STM32F10x_FWLib\inc;.\SYSTEM;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\SYSTEM\KEY;.\SYSTEM\key;.\SYSTEM\motor;.\SYSTEM\bldc;.\SYSTEM\encoder;.\SYSTEM\TIM2_Cap;.\SYSTEM\tim1;.\SYSTEM\adc_electricity;.\CONTROL\control;.\Driver\OLED_I2C
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: stm32f10x_it.c system_stm32f10x.c MiniBalance.c
  group CORE
    ./MiniBalance_COER/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c vofa_firewater.c vofa_firewater.h
    ./SYSTEM/motor/: f32c_motor.c f32c_motor.h f32c_gimbal.c f32c_gimbal.h
  group BLDC
    ./SYSTEM/bldc/: bldc_motor.c bldc_motor.h bldc_circle.c bldc_circle.h vision_pid.c vision_pid.h
  group OLED_I2C
    ./Driver/OLED_I2C/: oled_hardware_i2c.c oled_hardware_i2c.h oledfont.h
software components: CMSIS:CORE 5.6.0
